# Keil uVision project M487_OFFLINE.uvproj, settings and files
target M487_ISPBRIDGE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: M487_ISPBRIDGE
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG_ENABLE_SEMIHOST
  c misc: --c99
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\M480\Include
  asm define: DEBUG_ENABLE_SEMIHOST
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_M480.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../../Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group User
    ../: ISP_UART_BUS.c ISP_DRIVER.C SPI_FLASH_SPIM.C ISP_CAN_BUS.C ISP_SPI_BUS.c ISP_I2C_BUS.C ISP_RS485_BUS.c ISP_CMD.c main_offline.c
  group Library
    ../: NULIB.lib
